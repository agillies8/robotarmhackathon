Commit message: updated IK model

File: urdf/arm_urdf.urdf (robot description, URDF)
Before this commit: robot robotarmhackathon, 10 links, 9 joints
Links:
- added link world
Joints:
- added joint world_joint: type fixed, parent world, child base_link, origin xyz=-0.1 0.05 0 rpy=0 0 0
